# Keil uVision project LPC1768_LM35_Interfacing.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LPC1768_ADC_Ex_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: ocf_lpc176x_lib.h main.c ocf_lpc176x_lib.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
